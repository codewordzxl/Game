# Keil uVision project Pro.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c oled.c Game.c Delay.c
